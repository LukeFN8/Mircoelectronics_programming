# Keil uVision project test project1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051 Core CAST, Inc.
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: test project1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: test1.c
